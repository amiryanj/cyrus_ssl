# Keil uVision project FR.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: FR +hex
  AfterMake: fromelf --bin ".\FR.axf" --output ".\\FR.bin"
  c flags: Optim=1
  asm define: NO_CRP
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s Main.c defines.h pwm.c pwm.h uart.c uart.h RIT.c RIT.h Timer.c Timer.h system_LPC17xx.c exti.c exti.h GPIO.c GPIO.h delay.c delay.h
